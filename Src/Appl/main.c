/**********************************************************************************************************************
 *  FILE DESCRIPTION
 *  -----------------------------------------------------------------------------------------------------------------*/
/**        \file  main.c
 *        \brief  
 *
 *      \details  
 *
 *
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  INCLUDES
 *********************************************************************************************************************/
#include "../Config/Inc/Intctrl.h"
#include "../MCAL/Inc/DIO.h"
#include "../MCAL/Inc/Port.h"
#include "../MCAL/Inc/SysTick.h"
/**********************************************************************************************************************
*  LOCAL MACROS CONSTANT\FUNCTION
*********************************************************************************************************************/

/**********************************************************************************************************************
 *  LOCAL DATA 
 *********************************************************************************************************************/

/**********************************************************************************************************************
 *  GLOBAL DATA
 *********************************************************************************************************************/
static volatile int x = 0;
static volatile int Cnt = 0;
static volatile int F = 0;
/**********************************************************************************************************************
 *  LOCAL FUNCTION PROTOTYPES
 *********************************************************************************************************************/
void Sys_Tick_Notification(void);
/**********************************************************************************************************************
 *  LOCAL FUNCTIONS
 *********************************************************************************************************************/
void LED_ON(uint8 time);
void LED_OFF(uint8 time);
/**********************************************************************************************************************
 *  GLOBAL FUNCTIONS
 *********************************************************************************************************************/


/******************************************************************************
* \Syntax          : int main(void)        
* \Description     : superloop function to run the required task                                    
*                                                                             
* \Sync\Async      : Synchronous                                               
* \Reentrancy      : Reentrant                                             
* \Parameters (in) : None   Parameter Describtion                     
* \Parameters (out): None                                                      
* \Return value:   : int             E_OK
*                                    E_NOT_OK                                  
*******************************************************************************/
int main(void)
{
	IntCtrl_init();
	Port_Init(Ports);
	SysTick_Init(Count_Value);
	
	while(1){
	
	}
	
	return 0;
}
void Sys_Tick_Notification(void){
	

	Cnt++;
	
	if(Dio_ReadChannel(F1) == Hi){
		LED_ON(F0);
	}else if(Dio_ReadChannel(F2) == Hi){
		LED_OFF(F0);
	}
	
}
void LED_ON(uint8 Bit){
	//if((time == Cnt)&&(0 == F)){
		Dio_WriteChannel(Bit, Hi);
		//SysTick_Init(Count_Value);
	}
void LED_OFF(uint8 Bit){

		//SysTick_Init(Count_Value);
	Dio_WriteChannel(Bit, Lo);
}
/**********************************************************************************************************************
 *  END OF FILE: main.c
 *********************************************************************************************************************/
